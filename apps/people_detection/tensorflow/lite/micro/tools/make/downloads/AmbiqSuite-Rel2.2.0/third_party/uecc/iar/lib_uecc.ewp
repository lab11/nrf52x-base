# IAR project lib_uecc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAPH1KK-KBR AmbiqMicro AMAPH1KK-KBR
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; uECC_ENABLE_VLI_API=0; SEC_ECC_CFG=SEC_ECC_CFG_UECC; uECC_OPTIMIZATION_LEVEL=3; AM_PACKAGE_BGA; AM_PART_APOLLO3; uECC_SQUARE_FUNC=0; uECC_VLI_NATIVE_LITTLE_ENDIAN=1; uECC_SUPPORT_COMPRESSED_POINT=0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\micro-ecc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\micro-ecc
  OBJCOPY.OOCOutputFile: lib_uecc.bin
  ILINK.IlinkOutputFile: lib_uecc.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  group (top)
    ../micro-ecc/: uECC.c uECC.c
