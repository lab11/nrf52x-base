# IAR project ot_nrf52811_libopenthread_rcp_spi_nrf52811.ewp, settings and files
configuration libopenthread_rcp_spi_nrf52811 (ARM)
  General.OGChipSelectEditMenu: nrf52811_xxaa nRF52811_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DISABLE_CC310=1; FLOAT_ABI_SOFT; HAVE_CONFIG_H; MBEDTLS_CONFIG_FILE="mbedtls-config.h"; MBEDTLS_USER_CONFIG_FILE="nrf52811-mbedtls-config.h"; NRF52811_XXAA; OPENTHREAD_CONFIG_BORDER_ROUTER_ENABLE=1; OPENTHREAD_CONFIG_COAP_API_ENABLE=1; OPENTHREAD_CONFIG_DIAG_ENABLE=1; OPENTHREAD_CONFIG_DNS_CLIENT_ENABLE=1; OPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=1; OPENTHREAD_CONFIG_HEAP_EXTERNAL_ENABLE=1; OPENTHREAD_CONFIG_IP6_SLAAC_ENABLE=1; OPENTHREAD_CONFIG_LINK_RAW_ENABLE=1; OPENTHREAD_CONFIG_MAC_FILTER_ENABLE=1; OPENTHREAD_CONFIG_NCP_SPI_ENABLE=1; OPENTHREAD_CONFIG_NCP_UART_ENABLE=0; OPENTHREAD_CONFIG_TMF_NETWORK_DIAG_MTD_ENABLE=1; OPENTHREAD_CORE_CONFIG_PLATFORM_CHECK_FILE="openthread-core-nrf52811-config-check.h"; OPENTHREAD_ENABLE_NCP_SPINEL_ENCRYPTER=0; OPENTHREAD_ENABLE_POSIX_APP_DAEMON=0; OPENTHREAD_ENABLE_VENDOR_EXTENSION=0; OPENTHREAD_PLATFORM_POSIX_APP=0; OPENTHREAD_PROJECT_CORE_CONFIG_FILE="openthread-core-nrf52811-config.h"; OPENTHREAD_RADIO=1; SPINEL_PLATFORM_HEADER="spinel_platform.h"; SPIS_AS_SERIAL_TRANSPORT=1; _BSD_SOURCE=1; _DEFAULT_SOURCE=1; _GNU_SOURCE
  ICCARM.CCIncludePath2: ..\..\..\..\config; ..\..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\config; ..\..\..\..; ..\..\..\..\..\openthread\examples\platforms\nrf528xx\nrf52811; ..\..\..\..\..\openthread\include; ..\..\..\..\..\openthread\src; ..\..\..\..\..\openthread\src\core; ..\..\..\..\..\openthread\src\ncp; ..\..\..\..\..\openthread\third_party; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\crypto; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_security\mbedtls_plat_config; ..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk; ..\..\..\..\..\openthread\third_party\mbedtls\repo\include; ..\..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ot_nrf52811_libopenthread_rcp_spi_nrf52811.hex
  ILINK.IlinkOutputFile: ot_nrf52811_libopenthread_rcp_spi_nrf52811.out
  ILINK.IlinkIcfFile: ot_nrf52811_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group openthread
    ../../../../../openthread/src/ncp/: changed_props_set.cpp hdlc.cpp ncp_base.cpp ncp_base_dispatcher.cpp ncp_base_ftd.cpp ncp_base_mtd.cpp ncp_base_radio.cpp ncp_buffer.cpp ncp_spi.cpp ncp_uart.cpp spinel.c spinel_decoder.cpp spinel_encoder.cpp
