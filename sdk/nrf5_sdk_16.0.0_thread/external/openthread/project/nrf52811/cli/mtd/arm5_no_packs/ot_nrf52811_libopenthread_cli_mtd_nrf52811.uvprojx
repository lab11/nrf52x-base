# Keil uVision project ot_nrf52811_libopenthread_cli_mtd_nrf52811.uvprojx, settings and files
target libopenthread_cli_mtd_nrf52811 (ARM-ADS)
  device: nRF52811_xxAA Nordic Semiconductor
  pack: ..
  output: libopenthread-cli-mtd-nrf52811 (library)
  c flags: Optim=s OneElfS=1 uC99=1
  c define: DISABLE_CC310=1 FLOAT_ABI_SOFT HAVE_CONFIG_H MBEDTLS_CONFIG_FILE=\"mbedtls-config.h\" MBEDTLS_USER_CONFIG_FILE=\"nrf52811-mbedtls-config.h\" NRF52811_XXAA OPENTHREAD_CONFIG_BORDER_ROUTER_ENABLE=1 OPENTHREAD_CONFIG_COAP_API_ENABLE=1 OPENTHREAD_CONFIG_DIAG_ENABLE=1 OPENTHREAD_CONFIG_DNS_CLIENT_ENABLE=1 OPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=1 OPENTHREAD_CONFIG_HEAP_EXTERNAL_ENABLE=1 OPENTHREAD_CONFIG_IP6_SLAAC_ENABLE=1 OPENTHREAD_CONFIG_LINK_RAW_ENABLE=1 OPENTHREAD_CONFIG_MAC_FILTER_ENABLE=1 OPENTHREAD_CONFIG_NCP_UART_ENABLE=1 OPENTHREAD_CONFIG_THREAD_VERSION=2 OPENTHREAD_CONFIG_TMF_NETWORK_DIAG_MTD_ENABLE=1 OPENTHREAD_CORE_CONFIG_PLATFORM_CHECK_FILE=\"openthread-core-nrf52811-config-check.h\" OPENTHREAD_ENABLE_NCP_SPINEL_ENCRYPTER=0 OPENTHREAD_ENABLE_VENDOR_EXTENSION=0 OPENTHREAD_EXAMPLES_SIMULATION=0 OPENTHREAD_FTD=0 OPENTHREAD_MTD=1 OPENTHREAD_PLATFORM_POSIX=0 OPENTHREAD_POSIX=0 OPENTHREAD_POSIX_CONFIG_DAEMON_ENABLE=0 OPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52811-config.h\" OPENTHREAD_RADIO=0 UART_AS_SERIAL_TRANSPORT=1 __HEAP_SIZE=4096 __STACK_SIZE=4096
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\config;..\..\..;..\..\..\..\openthread\examples\platforms\nrf528xx\nrf52811;..\..\..\..\openthread\include;..\..\..\..\openthread\src;..\..\..\..\openthread\src\cli;..\..\..\..\openthread\src\core;..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis;..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_security\mbedtls_plat_config;..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk;..\..\..\..\openthread\third_party\mbedtls\repo\include;..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  asm define: as above
  asm misc: --cpreproc_opts=-DDISABLE_CC310=1,-DFLOAT_ABI_SOFT,-DHAVE_CONFIG_H,-DMBEDTLS_CONFIG_FILE=\"mbedtls-config.h\",-DMBEDTLS_USER_CONFIG_FILE=\"nrf52811-mbedtls-config.h\",-DNRF52811_XXAA,-DOPENTHREAD_CONFIG_BORDER_ROUTER_ENABLE=1,-DOPENTHREAD_CONFIG_COAP_API_ENABLE=1,-DOPENTHREAD_CONFIG_DIAG_ENABLE=1,-DOPENTHREAD_CONFIG_DNS_CLIENT_ENABLE=1,-DOPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=1,-DOPENTHREAD_CONFIG_HEAP_EXTERNAL_ENABLE=1,-DOPENTHREAD_CONFIG_IP6_SLAAC_ENABLE=1,-DOPENTHREAD_CONFIG_LINK_RAW_ENABLE=1,-DOPENTHREAD_CONFIG_MAC_FILTER_ENABLE=1,-DOPENTHREAD_CONFIG_NCP_UART_ENABLE=1,-DOPENTHREAD_CONFIG_THREAD_VERSION=2,-DOPENTHREAD_CONFIG_TMF_NETWORK_DIAG_MTD_ENABLE=1,-DOPENTHREAD_CORE_CONFIG_PLATFORM_CHECK_FILE=\"openthread-core-nrf52811-config-check.h\",-DOPENTHREAD_ENABLE_NCP_SPINEL_ENCRYPTER=0,-DOPENTHREAD_ENABLE_VENDOR_EXTENSION=0,-DOPENTHREAD_EXAMPLES_SIMULATION=0,-DOPENTHREAD_FTD=0,-DOPENTHREAD_MTD=1,-DOPENTHREAD_PLATFORM_POSIX=0,-DOPENTHREAD_POSIX=0,-DOPENTHREAD_POSIX_CONFIG_DAEMON_ENABLE=0,-DOPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52811-config.h\",-DOPENTHREAD_RADIO=0,-DUART_AS_SERIAL_TRANSPORT=1,-D__HEAP_SIZE=4096,-D__STACK_SIZE=4096
  asm include: as above
  library: MicroLIB
  link misc: --diag_suppress 6330
  group openthread
    ../../../../openthread/src/cli/: cli.cpp cli_coap.cpp cli_coap_secure.cpp cli_commissioner.cpp cli_console.cpp cli_dataset.cpp cli_joiner.cpp cli_server.cpp cli_uart.cpp cli_udp.cpp
