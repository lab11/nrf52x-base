# IAR project ot_nrf52811_libopenthread_nrf52811_transport_spi.ewp, settings and files
configuration libopenthread_nrf52811_transport_spi (ARM)
  General.OGChipSelectEditMenu: nrf52811_xxaa nRF52811_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CONFIG_GPIO_AS_PINRESET; DISABLE_CC310=1; FLOAT_ABI_SOFT; HAVE_CONFIG_H; MBEDTLS_CONFIG_FILE="mbedtls-config.h"; MBEDTLS_USER_CONFIG_FILE="nrf52811-mbedtls-config.h"; NRF52811_XXAA; OPENTHREAD_CONFIG_BORDER_ROUTER_ENABLE=1; OPENTHREAD_CONFIG_COAP_API_ENABLE=1; OPENTHREAD_CONFIG_DIAG_ENABLE=1; OPENTHREAD_CONFIG_DNS_CLIENT_ENABLE=1; OPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=1; OPENTHREAD_CONFIG_HEAP_EXTERNAL_ENABLE=1; OPENTHREAD_CONFIG_IP6_SLAAC_ENABLE=1; OPENTHREAD_CONFIG_LINK_RAW_ENABLE=1; OPENTHREAD_CONFIG_MAC_FILTER_ENABLE=1; OPENTHREAD_CONFIG_NCP_SPI_ENABLE=1; OPENTHREAD_CONFIG_NCP_UART_ENABLE=0; OPENTHREAD_CONFIG_THREAD_VERSION=2; OPENTHREAD_CONFIG_TMF_NETWORK_DIAG_MTD_ENABLE=1; OPENTHREAD_CORE_CONFIG_PLATFORM_CHECK_FILE="openthread-core-nrf52811-config-check.h"; OPENTHREAD_ENABLE_NCP_SPINEL_ENCRYPTER=0; OPENTHREAD_ENABLE_VENDOR_EXTENSION=0; OPENTHREAD_EXAMPLES_SIMULATION=0; OPENTHREAD_PLATFORM_POSIX=0; OPENTHREAD_POSIX_CONFIG_DAEMON_ENABLE=0; OPENTHREAD_PROJECT_CORE_CONFIG_FILE="openthread-core-nrf52811-config.h"; SPIS_AS_SERIAL_TRANSPORT=1; USE_APP_CONFIG=1
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\openthread\examples\platforms; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio; ..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\config; ..\..\..; ..\..\..\..\openthread\examples\platforms\nrf528xx; ..\..\..\..\openthread\examples\platforms\nrf528xx\nrf52811; ..\..\..\..\openthread\examples\platforms\nrf528xx\src; ..\..\..\..\openthread\examples\platforms\nrf528xx\src\transport; ..\..\..\..\openthread\include; ..\..\..\..\openthread\src\core; ..\..\..\..\openthread\third_party\NordicSemiconductor; ..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis; ..\..\..\..\openthread\third_party\NordicSemiconductor\config; ..\..\..\..\openthread\third_party\NordicSemiconductor\config\nrf52811\config; ..\..\..\..\openthread\third_party\NordicSemiconductor\dependencies; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\clock; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\common; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\power; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\fem\three_pin_gpio; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\mac_features; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\mac_features\ack_generator; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\platform\lp_timer; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\platform\temperature; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\rsch; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\radio\rsch\raal; ..\..\..\..\openthread\third_party\NordicSemiconductor\drivers\systick; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\app_error; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atfifo; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\atomic; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\block_dev; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\delay; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_security\mbedtls_plat_config; ..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\utf_converter; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\drivers; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\drivers\include; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\hal; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk; ..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\soc; ..\..\..\..\openthread\third_party\mbedtls\repo\include; ..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ot_nrf52811_libopenthread_nrf52811_transport_spi.hex
  ILINK.IlinkOutputFile: ot_nrf52811_libopenthread_nrf52811_transport_spi.out
  ILINK.IlinkIcfFile: ot_nrf52811_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group openthread
    ../../../../openthread/examples/platforms/nrf528xx/src/transport/: spi-slave.c transport.c uart.c
