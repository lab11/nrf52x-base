<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\core\mtd\iar\ot_nrf52811_libopenthread_mtd_nrf52811.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\rcp\uart\iar\ot_nrf52811_libopenthread_rcp_nrf52811.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\lib\hdlc\iar\ot_nrf52811_libopenthread_hdlc_nrf52811.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\rcp\spi\iar\ot_nrf52811_libopenthread_rcp_spi_nrf52811.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\cli\mtd\iar\ot_nrf52811_libopenthread_cli_mtd_nrf52811.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\core\radio\iar\ot_nrf52811_libopenthread_radio_nrf52811.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\mbedcrypto\cc310\iar\ot_nrf52811_libmbedcrypto_nrf52811.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\lib\spinel_ncp\iar\ot_nrf52811_libopenthread_spinel_ncp_nrf52811.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\plat_utils\iar\ot_nrf52811_libopenthread_platform_utils_nrf52811.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\lib\spinel_rcp\iar\ot_nrf52811_libopenthread_spinel_rcp_nrf52811.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\plat_nrf52811\sdk-nosd\iar\ot_nrf52811_libopenthread_nrf52811_sdk.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\plat_nrf52811\uart\iar\ot_nrf52811_libopenthread_nrf52811_transport.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\plat_nrf52811\spi\iar\ot_nrf52811_libopenthread_nrf52811_transport_spi.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\nordicsemi_nrf52811\driver\iar\ot_nrf52811_libnordicsemi_nrf52811_radio_driver.ewp</path>
  </project>  <project>
    <path>$WS_DIR$\plat_nrf52811\no-transport\iar\ot_nrf52811_libopenthread_nrf52811_transport_none.ewp</path>
  </project>  <batchBuild/>
</workspace>