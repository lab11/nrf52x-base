# Keil uVision project ot_nrf52833_libopenthread_ncp_mtd_spi_nrf52833.uvprojx, settings and files
target libopenthread_ncp_mtd_spi_nrf52833 (ARM-ADS)
  device: nRF52833_xxAA Nordic Semiconductor
  pack: ..
  output: libopenthread-ncp-mtd-spi-nrf52833 (library)
  c flags: Optim=s OneElfS=1 uC99=1
  c define: DISABLE_CC310=1 FLOAT_ABI_HARD HAVE_CONFIG_H MBEDTLS_CONFIG_FILE=\"mbedtls-config.h\" MBEDTLS_USER_CONFIG_FILE=\"nrf52833-mbedtls-config.h\" NRF52833_XXAA OPENTHREAD_CONFIG_BORDER_AGENT_ENABLE=1 OPENTHREAD_CONFIG_BORDER_ROUTER_ENABLE=1 OPENTHREAD_CONFIG_CHILD_SUPERVISION_ENABLE=1 OPENTHREAD_CONFIG_COAP_API_ENABLE=1 OPENTHREAD_CONFIG_COAP_SECURE_API_ENABLE=1 OPENTHREAD_CONFIG_COMMISSIONER_ENABLE=1 OPENTHREAD_CONFIG_DHCP6_CLIENT_ENABLE=1 OPENTHREAD_CONFIG_DHCP6_SERVER_ENABLE=1 OPENTHREAD_CONFIG_DIAG_ENABLE=1 OPENTHREAD_CONFIG_DNS_CLIENT_ENABLE=1 OPENTHREAD_CONFIG_ECDSA_ENABLE=1 OPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=1 OPENTHREAD_CONFIG_HEAP_EXTERNAL_ENABLE=1 OPENTHREAD_CONFIG_IP6_SLAAC_ENABLE=1 OPENTHREAD_CONFIG_JAM_DETECTION_ENABLE=1 OPENTHREAD_CONFIG_JOINER_ENABLE=1 OPENTHREAD_CONFIG_LINK_RAW_ENABLE=1 OPENTHREAD_CONFIG_MAC_FILTER_ENABLE=1 OPENTHREAD_CONFIG_NCP_SPI_ENABLE=1 OPENTHREAD_CONFIG_NCP_UART_ENABLE=0 OPENTHREAD_CONFIG_SNTP_CLIENT_ENABLE=1 OPENTHREAD_CONFIG_THREAD_VERSION=2 OPENTHREAD_CONFIG_TMF_NETDATA_SERVICE_ENABLE=1 OPENTHREAD_CONFIG_TMF_NETWORK_DIAG_MTD_ENABLE=1 OPENTHREAD_CONFIG_UDP_FORWARD_ENABLE=1 OPENTHREAD_CORE_CONFIG_PLATFORM_CHECK_FILE=\"openthread-core-nrf52833-config-check.h\" OPENTHREAD_ENABLE_NCP_SPINEL_ENCRYPTER=0 OPENTHREAD_ENABLE_VENDOR_EXTENSION=0 OPENTHREAD_EXAMPLES_SIMULATION=0 OPENTHREAD_FTD=0 OPENTHREAD_MTD=1 OPENTHREAD_PLATFORM_POSIX=0 OPENTHREAD_POSIX_CONFIG_DAEMON_ENABLE=0 OPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52833-config.h\" OPENTHREAD_RADIO=0 OPENTHREAD_SPINEL_CONFIG_OPENTHREAD_MESSAGE_ENABLE=1 SPINEL_PLATFORM_HEADER=\"spinel_platform.h\" SPIS_AS_SERIAL_TRANSPORT=1 _GNU_SOURCE __HEAP_SIZE=4096 __STACK_SIZE=4096
  c misc: --reduce_paths
  c include: ..\..\..\..\config;..\..\..\..\..\config;..\..\..\..;..\..\..\..\..\openthread\examples\platforms\nrf528xx\nrf52833;..\..\..\..\..\openthread\include;..\..\..\..\..\openthread\src;..\..\..\..\..\openthread\src\core;..\..\..\..\..\openthread\src\ncp;..\..\..\..\..\openthread\third_party;..\..\..\..\..\openthread\third_party\NordicSemiconductor\cmsis;..\..\..\..\..\openthread\third_party\NordicSemiconductor\libraries\nrf_security\mbedtls_plat_config;..\..\..\..\..\openthread\third_party\NordicSemiconductor\nrfx\mdk;..\..\..\..\..\openthread\third_party\mbedtls\repo\include;..\..\..\..\..\openthread\third_party\mbedtls\repo\include\mbedtls
  asm define: as above
  asm misc: --cpreproc_opts=-DDISABLE_CC310=1,-DFLOAT_ABI_HARD,-DHAVE_CONFIG_H,-DMBEDTLS_CONFIG_FILE=\"mbedtls-config.h\",-DMBEDTLS_USER_CONFIG_FILE=\"nrf52833-mbedtls-config.h\",-DNRF52833_XXAA,-DOPENTHREAD_CONFIG_BORDER_AGENT_ENABLE=1,-DOPENTHREAD_CONFIG_BORDER_ROUTER_ENABLE=1,-DOPENTHREAD_CONFIG_CHILD_SUPERVISION_ENABLE=1,-DOPENTHREAD_CONFIG_COAP_API_ENABLE=1,-DOPENTHREAD_CONFIG_COAP_SECURE_API_ENABLE=1,-DOPENTHREAD_CONFIG_COMMISSIONER_ENABLE=1,-DOPENTHREAD_CONFIG_DHCP6_CLIENT_ENABLE=1,-DOPENTHREAD_CONFIG_DHCP6_SERVER_ENABLE=1,-DOPENTHREAD_CONFIG_DIAG_ENABLE=1,-DOPENTHREAD_CONFIG_DNS_CLIENT_ENABLE=1,-DOPENTHREAD_CONFIG_ECDSA_ENABLE=1,-DOPENTHREAD_CONFIG_ENABLE_BUILTIN_MBEDTLS=1,-DOPENTHREAD_CONFIG_HEAP_EXTERNAL_ENABLE=1,-DOPENTHREAD_CONFIG_IP6_SLAAC_ENABLE=1,-DOPENTHREAD_CONFIG_JAM_DETECTION_ENABLE=1,-DOPENTHREAD_CONFIG_JOINER_ENABLE=1,-DOPENTHREAD_CONFIG_LINK_RAW_ENABLE=1,-DOPENTHREAD_CONFIG_MAC_FILTER_ENABLE=1,-DOPENTHREAD_CONFIG_NCP_SPI_ENABLE=1,-DOPENTHREAD_CONFIG_NCP_UART_ENABLE=0,-DOPENTHREAD_CONFIG_SNTP_CLIENT_ENABLE=1,-DOPENTHREAD_CONFIG_THREAD_VERSION=2,-DOPENTHREAD_CONFIG_TMF_NETDATA_SERVICE_ENABLE=1,-DOPENTHREAD_CONFIG_TMF_NETWORK_DIAG_MTD_ENABLE=1,-DOPENTHREAD_CONFIG_UDP_FORWARD_ENABLE=1,-DOPENTHREAD_CORE_CONFIG_PLATFORM_CHECK_FILE=\"openthread-core-nrf52833-config-check.h\",-DOPENTHREAD_ENABLE_NCP_SPINEL_ENCRYPTER=0,-DOPENTHREAD_ENABLE_VENDOR_EXTENSION=0,-DOPENTHREAD_EXAMPLES_SIMULATION=0,-DOPENTHREAD_FTD=0,-DOPENTHREAD_MTD=1,-DOPENTHREAD_PLATFORM_POSIX=0,-DOPENTHREAD_POSIX_CONFIG_DAEMON_ENABLE=0,-DOPENTHREAD_PROJECT_CORE_CONFIG_FILE=\"openthread-core-nrf52833-config.h\",-DOPENTHREAD_RADIO=0,-DOPENTHREAD_SPINEL_CONFIG_OPENTHREAD_MESSAGE_ENABLE=1,-DSPINEL_PLATFORM_HEADER=\"spinel_platform.h\",-DSPIS_AS_SERIAL_TRANSPORT=1,-D_GNU_SOURCE,-D__HEAP_SIZE=4096,-D__STACK_SIZE=4096
  asm include: as above
  library: MicroLIB
  link misc: --diag_suppress 6330
  group openthread
    ../../../../../openthread/src/ncp/: changed_props_set.cpp ncp_base.cpp ncp_base_dispatcher.cpp ncp_base_ftd.cpp ncp_base_mtd.cpp ncp_base_radio.cpp ncp_spi.cpp ncp_uart.cpp
